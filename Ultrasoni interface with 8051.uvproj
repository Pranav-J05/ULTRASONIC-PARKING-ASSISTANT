# Keil uVision project Ultrasoni interface with 8051.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: mpmc proj +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: find_distance.c LCD_8_bit.c LCD_8_bit.h
